options:
  parameters:
    description: Voice FM simulation (mic -> NBFM TX -> noisy channel -> NBFM RX -> speaker)
    generate_options: qt_gui
    id: voice_fm_sim
    output_language: python
    title: Voice FM Simulation
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: tau
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0.1'
    step: '0.1'
    stop: '2.0'
    value: '1.0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0.0'
    step: '0.1'
    stop: '3.0'
    value: '1.0'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: max_dev
    quad_rate: quad_rate
    tau: tau
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: max_dev
    quad_rate: quad_rate
    tau: tau
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: audio_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: default
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0+0.0j]'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3400'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    name: '"Mic Audio"'
    plotconst: 'False'
    plotfreq: 'False'
    plotwaterfall: 'False'
    type: float
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '2048'
    name: '"FM Channel"'
    plotconst: 'False'
    plottime: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    name: '"Recovered Audio"'
    plotconst: 'False'
    plotfreq: 'False'
    plotwaterfall: 'False'
    type: float
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_2, '0']
- [channels_channel_model_0, '0', analog_nbfm_rx_0, '0']
- [channels_channel_model_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
